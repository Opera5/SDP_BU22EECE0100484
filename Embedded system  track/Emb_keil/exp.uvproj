# Keil uVision project exp.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C51 ISSI
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(40000000)
  output: exp1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 blink_LED.c
